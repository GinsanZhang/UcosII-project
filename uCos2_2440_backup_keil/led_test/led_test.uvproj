# Keil uVision project led_test.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: S3C2440A Samsung
  cpu: IRAM(0x40000000-0x40000FFF) CLOCK(12000000) CPUTYPE(ARM920T)
  output: led_test
  AfterMake: fromelf.exe --bin -o  .\obj\@p.bin  .\obj\@p.axf
  c flags: Optim=1
  c include: ..\common\inc;..\led_test;..\uCOS_II\API;..\uCOS_II\arm;..\uCOS_II\SOURCE;.\inc
  memory RVCT1: ROM 0x0 size 0x200000
  memory RVCT6: RAM 0x30800000 size 0x800000
  memory RVCT9: RAM 0x40000000 size 0x1000
  scatter file: .\obj\led_test.sct
  group Startup
    ../common/src/: S3C2440A.s
  group Common Files
    ../common/src/: 2440lib.c
  group Source Files
    ./: led_test.c main.c
    ../common/src/: nandflash.c
  group ucos_ii
    ../uCOS_II/arm/: Os_cpu_a.s Os_cpu_c.c OS_CPU.H
    ../uCOS_II/SOURCE/: os_cfg.h os_core.c os_dbg_r.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c ucos_ii.h
    ../uCOS_II/API/: app_cfg.h
